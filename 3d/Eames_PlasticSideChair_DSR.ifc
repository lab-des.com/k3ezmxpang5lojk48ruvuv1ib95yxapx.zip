Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2019-01-31T16:45:34
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150220_1215(x64) - Exporter 16.6.0.0 - Alternate UI 16.6.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Jan 31 16:45:34 2019 * Host: DESKTOP-JLKK7TQ * Database: C:\Users\vladb\AppData\Local\Temp\{4563D65C-BDD3-479D-871C-57683179BF39}\ifc * Database version: 5507 * Database creation date: Thu Jan 31 16:45:33 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Jan 31 16:45:34 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Jan 31 16:45:34 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 30, 344238; RefLongitude: -71, -3, -35, -194702; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFurnishingElement: Eames plastic side chair DSR with seat cushion, CONV_Vitra_DmstcChrs_Eames_PlasticSideChair_DSR:Eames plastic side chair DSR with seat cushion:319072
In: Level 1
Material: 01 chrome, Glide black, Textile hopsak nero 66, 01 basic dark
Pset_ManufacturerTypeInformation - ModelReference: 44030100; Manufacturer: Vitra
Constraints - Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm
Dimensions - Area: 1.09826 m2; Volume: 0.212291 m3
Materials and Finishes - ChairMainMaterial: 01 basic dark; ChairQuaternaryMaterial: Glide black; ChairSecondaryMaterial: Textile hopsak nero 66
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Furniture; Family: CONV_Vitra_DmstcChrs_Eames_PlasticSideChair_DSR: Eames plastic side chair DSR with seat cushion; Family and Type: CONV_Vitra_DmstcChrs_Eames_PlasticSideChair_DSR: Eames plastic side chair DSR with seat cushion; InstallationDate: n/a; Material: Polypropylene, aluminium & textile; SerialNumber: n/a; TagNumber: n/a; Type: CONV_Vitra_DmstcChrs_Eames_PlasticSideChair_DSR: Eames plastic side chair DSR with seat cushion; Type Id: CONV_Vitra_DmstcChrs_Eames_PlasticSideChair_DSR: Eames plastic side chair DSR with seat cushion; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
Construction(Type) - SeatCushionVisibility: yes; SeatType: Eames_plastic_DSR_simplechair+cushion
General(Type) - Author: Convergo AB; BIMObjectName: CONV_Vitra_DmstcChrs_Eames_PlasticSideChair_DSR; ConvergoRefNr: 0089-1812-0005-CH; ManufacturerName: Vitra; ManufacturerURL: https://www.vitra.com/; NBSDescription: Domestic chairs; NBSReference: 45-35-20/365; ProductInformation: The so-called Eiffel Tower base of the DSR chair (Dining Height Side Chair Rod Base), an intricate and graceful construction made of steel wire, combines light, elegant forms with structural strength.; Revision: n/a; Uniclass2: Pr_40_50_12_48; Uniclass2015Description: Dining chairs; Uniclass2015Reference: Pr_40_50_12_22; Version: 1; VersionDate: 17/01/2019
Identity Data(Type) - Collection: Eames plastic side chair; Cost: 0; Description: The so-called Eiffel Tower base of the DSR chair (Dining Height Side Chair Rod Base), an intricate and graceful construction made of steel wire, combines light, elegant forms with structural strength. The organically shaped plastic seat shell is available in various colours and upholstery options, allowing this distinctive classic by Charles and Ray Eames to be adapted to a wide range of individual needs and preferences.; Designer: Charles & Ray Eames; Manufacturer: Vitra; Model: Eames plastic side chair DSR with seat cushion; OmniClass Number: 23.40.20.14.14.11; OmniClass Title: Chairs; ProductDatasheet: https://www.vitra.com/en-un/_storage/asset/970265/storage/master/download/Factbook%20EPC-EN.pdf; Type Name: Eames plastic side chair DSR with seat cushion; URL: https://www.vitra.com/en-un/living/product/details/eames-plastic-side-chair-dsr
Materials and Finishes(Type) - ChairTertiaryMaterial: 01 chrome
Other(Type) - AccessibilityPerformance: n/a; AssetType: Movable; Brand: Vitra; Category: Chairs; CodePerformance: n/a; Color: Various; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: CONV_Vitra_DmstcChrs_Eames_PlasticSideChair_DSR; Features: Optional seat cushion or full upholstery.; Finish: Seat shell: dyed-through polypropylene. All models are available with a seat cushion (screwed to the seat shell) or full upholstery. The fully upholstered version has moulded polyurethane foam padding covered in fabric, attached to the shell with a welted edge. Different shell and upholstery colours and various bases provide a multitude of possible combinations. Options: the Eames Plastic Chair is available as a visitor chair, dining chair, rocking chair, swivel chair or in stacking versions and with ganging brackets for row seating. Beam-mounted shells are suited for use in waiting areas. Base: non-stacking four-legged wire base with cross struts. The powder-coated version is suitable for outdoor use. (DSR = Dining Height Side Chair Rod Base). Note: special additives retard the fading of colours due to UV radiation. However, if the chair is exposed to sunlight for prolonged periods, the colour may change over time. We recommend limited exposure to sunlight.; Grade: n/a; ModelNumber: n/a; ModelReference: 44030100; Name: DmstcChrs_Eames_PlasticSideChair_DSR_Cushion; ReplacementCost: n/a; Shape: Sculptured; Size: 465x550x830 mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
